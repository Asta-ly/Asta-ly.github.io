# Keil uVision project ESP8266.uvprojx, settings and files
target ESP8266 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\LIB\inc;..\LIB\src;..\USER;..\HARDWARE;..\HARDWARE\onenet;..\HARDWARE\sg90;..\HARDWARE\BIT_BAND;..\HARDWARE\cJSON;..\HARDWARE\delay;..\HARDWARE\ESP8266;..\HARDWARE\LED;..\HARDWARE\MQTT;..\HARDWARE\onenet;..\HARDWARE\usart;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\RC522;..\HARDWARE\LIGHT;..\HARDWARE\MQ;..\HARDWARE\BMP280;..\HARDWARE\RAIN;..\HARDWARE\Stepper motor;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\oled;..\HARDWARE\tasks;..\HARDWARE\timer;..\HARDWARE\password;..\HARDWARE\w25q128
  asm include: ..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
  group core
    ../CORE/: startup_stm32f40_41xxx.s
  group fwlib
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group hardware
    ../HARDWARE/cJSON/: cJSON.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/MQTT/: MqttKit.c
    ../HARDWARE/onenet/: onenet.c
    ../HARDWARE/sg90/: pwm.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/BMP280/: BMP280.c
    ../HARDWARE/LIGHT/: LIGHT.c
    ../HARDWARE/MQ/: MQ2.c MQ135.c
    ../HARDWARE/RAIN/: RAIN.c
    ../HARDWARE/RC522/: MFRC522.c
    ../HARDWARE/Stepper motor/: Step.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/tasks/: tasks.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/password/: password.c
    ../HARDWARE/w25q128/: w25q128.c
